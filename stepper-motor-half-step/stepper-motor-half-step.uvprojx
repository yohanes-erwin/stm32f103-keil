# Keil uVision project stepper-motor-half-step.uvprojx, settings and files
target STM32F103C8 (ARM-ADS)
  device: STM32F102C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stepper-motor-half-step
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source
    ./: main.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.0.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
    RTE/Device/STM32F102C8/: RTE_Device.h startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
